IMAGE_INSTALL:append = " ssd1306-mod"
